## Config.in
```kconfig
config BR2_PACKAGE_YSYSLOGD
	bool "ysyslogd"
	help
	  Standalone syslog daemon with ring buffer
```
